# Keil uVision project N32G430C8L7-USBMeter.uvprojx, settings and files
target USBMeter (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: N32G430C8L7 Nationstech
  pack: Nationstech.N32G430_DFP.1.0.0
  cpu: IRAM(0x20000000,0x4000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: N32G430C8L7-USBMeter +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: N32G430, USE_STDPERIPH_DRIVER
  c include: .\Drivers\CMSIS\core;.\Drivers\CMSIS\device;.\Drivers\n32g430_std_periph_driver\inc;.\Core\inc;.\Lib\MonoScreen;.\Lib\SoftI2C;.\User;.\Lib\Key_Scanf;.\Lib\CH224K
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group Drivers/CMSIS
    ./Drivers/CMSIS/device/: system_n32g430.c
  group Drivers/N32G430_Library
    ./Drivers/n32g430_std_periph_driver/src/: misc.c n32g430_adc.c n32g430_beeper.c n32g430_can.c n32g430_comp.c n32g430_crc.c n32g430_dbg.c n32g430_dma.c n32g430_exti.c n32g430_flash.c n32g430_gpio.c n32g430_i2c.c n32g430_iwdg.c n32g430_lptim.c n32g430_pwr.c n32g430_rcc.c n32g430_rtc.c n32g430_spi.c n32g430_tim.c n32g430_usart.c n32g430_wwdg.c
  group Startup
    ./Startup/: startup_n32g430.s
  group Src
    ./Core/src/: bsp_delay.c bsp_iwdg.c main.c n32g430_it.c
  group Lib/MonoScreen
    ./Lib/MonoScreen/: fonts.c fonts.h MonoScreen.h MonoScreen.c
  group Lib/SoftI2C
    ./Lib/SoftI2C/: SoftI2c.h SoftI2c.c
  group Lib/Key_Scanf
    ./Lib/Key_Scanf/: KEY.c KEY.h
  group Lib/CH224K
    ./Lib/CH224K/: CH224K.c CH224K.h
  group Doc
    ./: Readme.md
